# Keil uVision project YX5200_TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: QYMxFS_TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: key.c Log.c main.c mylib.c SystemInit.c uart.c LCD1602.C
